<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\1.flight_hal_new.ewp</path>
  </project>
  <batchBuild />
</workspace>
